# IAR project wSpecXX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; _TARGET_IS_CC3200; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; _NOTERM; WSPEC; _WSPEC_BIG_RAM; _TESTING
  ICCARM.CCIncludePath2: ..; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\example\common; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\driverlib; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\inc; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\oslib; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\simplelink; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\simplelink\include; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\simplelink_extlib\provisioninglib; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\third_party\FreeRTOS\source\include; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: wSpecXX.bin
  ILINK.IlinkOutputFile: wSpecXX.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: C:\ti\CC3200SDK_1.2.0\cc3200-sdk\example\blinky\ewarm\cc3200.icf
  ILINK.IlinkAdditionalLibs: C:\ti\CC3200SDK_1.2.0\cc3200-sdk\simplelink\ewarm\OS\Exe\simplelink.a; C:\ti\CC3200SDK_1.2.0\cc3200-sdk\driverlib\ewarm\Release\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: audiocodec.c circ_buff.c control.c main.c microphone.c network.c pcm_handler.c pinmux.c smartconfig.c speaker.c
  group common
    ../../../../../../../../ti/CC3200SDK_1.2.0/cc3200-sdk/example/common/: gpio_if.c i2c_if.c i2s_if.c network_common.c startup_ewarm.c uart_if.c udma_if.c
  group freertos
    ../../../../../../../../ti/CC3200SDK_1.2.0/cc3200-sdk/third_party/FreeRTOS/source/: croutine.c list.c queue.c tasks.c timers.c
    ../: FreeRTOSConfig.h heap_4.c
    ../../../../../../../../ti/CC3200SDK_1.2.0/cc3200-sdk/oslib/: osi_freertos.c
    ../../../../../../../../ti/CC3200SDK_1.2.0/cc3200-sdk/third_party/FreeRTOS/source/portable/IAR/ARM_CM4/: port.c portasm.s
  group g711
    ../g711/: g711_c.c g711_s.s
  group rtp
    ../rtp/: rtp.c rtp.h rtpdata.h
